# Repository letoine/MegadriveControllerToUSB

File README.md:

MegadriveControllerToUSB
========================

Simple adapter that transforms a Megadrive/Genesis controller into a USB controller.

Megadrive controller pinout
===========================

pin | name         | comment
----|--------------|--------
 1  | data0        | 
 2  | data1        |
 3  | data2        |
 4  | data3        | 
 5  | +5V          | 
 6  | data4        | 
 7  | Select clock | 
 8  | GND          | 
 9  | data5        | 

Select clock |  data0   |  data1   |  data2   | data3 |    data4     |  data5 
-------------|----------|----------|----------|-------|--------------|---------
 High        | Up       | Down     | Left     | Right | C button     | B button
 Low         | Up       | Down     | 0        | 0     | Start button | A button
 High        | Up       | Down     | Left     | Right | C button     | B button
 Low         | 0        | 0        | 0        | 0     | Start button | A button
 High        | Z button | Y button | X button | Mode  | C button     | B button
 Low         | 1        | 1        | 1        | 1     | Start button | B button

## KiCad design hardware/MegadriveControllerToUSB.kicad_pcb

Parts:
C1, C2: 22p
C3, C5: 100nf
C4: 1uf
CON1: AVR-ISP6; AVR-ISP-6
J1: USB
J2: DB9
R1, R2: 22ohms
R3: 10K
U1: ATMEGA32U2-AU
X1: 16Mhz

Connections:
DATA0_PIN: J2.1, U1.12
DATA1_PIN: J2.2, U1.10
DATA2_PIN: J2.3, U1.8
DATA3_PIN: J2.4, U1.7
DATA4_PIN: J2.6, U1.11
DATA5_PIN: J2.9, U1.6
GND: C1.2, C2.2, C3.1, C4.1, C5.2, CON1.6 (GND), J1.4 (GND), J1.5 (Shield_1), J1.6 (Shield_2), J2.8, U1.3, U1.28
MISO: CON1.1 (MISO), U1.17
MOSI: CON1.4 (MOSI), U1.16
unnamed: C4.2, U1.27
unnamed: R1.2, U1.30
unnamed: J1.2 (D-), R1.1
unnamed: J1.3 (D+), R2.1
unnamed: R2.2, U1.29
unnamed: C2.1, U1.2, X1.2
unnamed: C1.1, U1.1, X1.1
RESET: C5.1, CON1.5 (RST), R3.2, U1.24
SCK: CON1.3 (SCK), U1.15
SELECT_CLK: J2.7, U1.9
VCC: C3.2, CON1.2 (VCC), J1.1 (Vbus), J2.5, R3.1, U1.4, U1.31, U1.32

Board: 2 copper layers, 32.5 x 44.2 mm, 13 parts (0 on the bottom side), 20 nets.

## Code that names these connections

File software/Joystick.c:

#include "Joystick.h"

static uint8_t PrevJoystickHIDReportBuffer[sizeof(USB_JoystickReport_Data_t)];

USB_ClassInfo_HID_Device_t Joystick_HID_Interface = {
  .Config = {
    .InterfaceNumber = INTERFACE_ID_Joystick,
    .ReportINEndpoint = {
      .Address              = JOYSTICK_EPADDR,
      .Size                 = JOYSTICK_EPSIZE,
      .Banks                = 1,
    },
    .PrevReportINBuffer           = PrevJoystickHIDReportBuffer,
    .PrevReportINBufferSize       = sizeof(PrevJoystickHIDReportBuffer),
  },
};

#define IO_PORT		PORTD
#define IO_DDR		DDRD
#define IO_PIN		PIND

#define DATA5_PIN	0
#define DATA3_PIN	1
#define DATA2_PIN	2
#define SELECT_PIN	3
#define DATA1_PIN	4
#define DATA4_PIN	5
#define DATA0_PIN	6

#define INPUT_PINS_MASK	(_BV(DATA0_PIN)|\
			 _BV(DATA1_PIN)|\
			 _BV(DATA2_PIN)|\
			 _BV(DATA3_PIN)|\
			 _BV(DATA4_PIN)|\
			 _BV(DATA5_PIN))
#define OUTPUT_PINS_MASK (_BV(SELECT_PIN))

typedef union {
  uint8_t raw;
  struct {
    unsigned int a:1;
    unsigned int right:1;
    unsigned int left:1;
    unsigned int :1;
    
    unsigned int down:1;
    unsigned int start:1;
    unsigned int up:1;
    unsigned int :1;
  };
  struct {
    unsigned int b:1;
    unsigned int mode:1;
    unsigned int x:1;
    unsigned int :1;
    
    unsigned int y:1;
    unsigned int c:1;
    unsigned int z:1;
    unsigned int :1;
  };
} input_defs;

inline void set_select_low(void) {
  IO_PORT &= ~(_BV(SELECT_PIN));
}

inline void set_select_high(void) {
  IO_PORT |= _BV(SELECT_PIN);
}

inline bool is_three_buttons_Frame(input_defs i) {
  return !i.left && !i.right;
}

inline bool is_six_buttons_Frame(input_defs i) {
  return !i.left && !i.right && !i.up && !i.down;
}

inline void set_directions(USB_JoystickReport_Data_t* JoystickReport, input_defs inputs) {
  if (!inputs.up)
    JoystickReport->Y = -127;
  else if (!inputs.down)
    JoystickReport->Y = 127;
  
  if (!inputs.left)
    JoystickReport->X = -127;
  else if (!inputs.right)
    JoystickReport->X = 127;
}

inline void read_two_buttons_frame(USB_JoystickReport_Data_t* JoystickReport, input_defs inputs) {
  set_directions(JoystickReport, inputs);
  
  if (!inputs.a)
    JoystickReport->button.square = 1;
  
  if (!inputs.start)
    JoystickReport->button.cross = 1;
}

inline void read_three_buttons_frames(USB_JoystickReport_Data_t* JoystickReport, input_defs inputs) {
  set_select_high();
  if (!inputs.a)
    JoystickReport->button.cross = 1;
  if (!inputs.start)
    JoystickReport->button.start = 1;
  inputs.raw = IO_PIN;
  set_select_low();
  
  set_directions(JoystickReport, inputs);
  if (!inputs.b)
    JoystickReport->button.circle = 1;
  if (!inputs.c)
    JoystickReport->button.square = 1;
}

inline void read_six_buttons_frames_internal(USB_JoystickReport_Data_t* JoystickReport) {
  input_defs inputs;
  inputs.raw = IO_PIN;
  set_select_high();
  if (!inputs.a)
    JoystickReport->button.cross = 1;
  if (!inputs.start)
    JoystickReport->button.start = 1;
  
  inputs.raw = PINB;
  set_select_low();
  set_directions(JoystickReport, inputs);
  if (!inputs.b)
    JoystickReport->button.square = 1;
  if (!inputs.c)
    JoystickReport->button.r1 = 1;
}

inline void read_six_buttons_frames(USB_JoystickReport_Data_t* JoystickReport, input_defs inputs) {
  set_select_high();
  if (!inputs.a)
    JoystickReport->button.cross = 1;
  if (!inputs.start)
    JoystickReport->button.start = 1;
  
  inputs.raw = PINB;
  set_select_low();
  if (!inputs.x)
    JoystickReport->button.circle = 1;
  if (!inputs.y)
    JoystickReport->button.triangle = 1;
  if (!inputs.z)
    JoystickReport->button.l1 = 1;
  //if (!inputs.mode)
  //  JoystickReport->button.select = 1;
  
  read_six_buttons_frames_internal(JoystickReport);
  read_six_buttons_frames_internal(JoystickReport);
  read_six_buttons_frames_internal(JoystickReport);
}

int main(void) {
  SetupHardware();
  
  GlobalInterruptEnable();
  
  for (;;) {
    HID_Device_USBTask(&Joystick_HID_Interface);
    USB_USBTask();
  }
}

void SetupHardware(void) {
  /* Disable watchdog if enabled by bootloader/fuses */
  MCUSR &= ~(1 << WDRF);
  wdt_disable();
  
  /* Disable clock division */
  clock_prescale_set(clock_div_1);
  
  /* Hardware Initialization */
  IO_DDR = OUTPUT_PINS_MASK;
  IO_PORT = INPUT_PINS_MASK;
  
  set_select_low();
  SerialDebug_init();
  USB_Init();
}

void EVENT_USB_Device_ConfigurationChanged(void) {
  bool ConfigSuccess = true;
  
  SerialDebug_printf("EVENT_USB_Device_ConfigurationChanged\r\n");
  ConfigSuccess &= HID_Device_ConfigureEndpoints(&Joystick_HID_Interface);
  
  USB_Device_EnableSOFEvents();
}

void EVENT_USB_Device_ControlRequest(void) {
  SerialDebug_printf("EVENT_USB_Device_ControlRequest\r\n");
  HID_Device_ProcessControlRequest(&Joystick_HID_Interface);
}

void EVENT_USB_Device_StartOfFrame(void) {
  //SerialDebug_printf("EVENT_USB_Device_StartOfFrame\r\n");
  HID_Device_MillisecondElapsed(&Joystick_HID_Interface);
}

bool CALLBACK_HID_Device_CreateHIDReport(USB_ClassInfo_HID_Device_t* const HIDInterfaceInfo,
                                         uint8_t* const ReportID,
                                         const uint8_t ReportType,
                                         void* ReportData,
                                         uint16_t* const ReportSize)
{
  USB_JoystickReport_Data_t* JoystickReport = (USB_JoystickReport_Data_t*)ReportData;
  input_defs inputs;
  
  set_select_low();
  JoystickReport->Y = 0;
  JoystickReport->X = 0;
  JoystickReport->button.raw[0] = 0;
  JoystickReport->button.raw[1] = 0;
  
  inputs.raw = PINB;
  if (is_six_buttons_Frame(inputs)) {
    // Most likely 6 buttons megadrive/genesis controller
    read_six_buttons_frames(JoystickReport, inputs);
  } else if (is_three_buttons_Frame(inputs)) {
    // Most likely 3 buttons megadrive/genesis controller
    read_three_buttons_frames(JoystickReport, inputs);
  } else {
    // Most likely MS controller.
    read_two_buttons_frame(JoystickReport, inputs);
  }
  
  *ReportSize = sizeof(USB_JoystickReport_Data_t);
  return false;
}

void CALLBACK_HID_Device_ProcessHIDReport(USB_ClassInfo_HID_Device_t* const HIDInterfaceInfo,
                                          const uint8_t ReportID,
                                          const uint8_t ReportType,
                                          const void* ReportData,
                                          const uint16_t ReportSize)
{
  SerialDebug_printf("CALLBACK_HID_Device_ProcessHIDReport\r\n");
  SerialDebug_printf("%#0x, %#0x\r\n", ReportID, ReportType);
  SerialDebug_printByteArray(ReportData, ReportSize);
  
  // Unused (but mandatory for the HID class driver) in this demo, since there are no Host->Device reports
}

## Commit log

2014-08-04 Adding project files. Basically a copy of NeoGeoControllertoUSB, replacing DB15 by DB9.
2014-08-05 Shrink board.
2014-11-13 Adding firmware. tested with master system controller on teensy. Need update hardware and test with other controllers.
2014-11-16 Set pin numbers properly. Need to test again. Removing some kicad temp files.

Notices in the files:
hardware/MegadriveControllerToUSB.kicad_pcb:
Copyright 2014 antoine terrienne
